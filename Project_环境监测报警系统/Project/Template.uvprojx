# Keil uVision project Template.uvprojx, settings and files
target 环境监测报警系统 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\User\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
  group USER
    ../User/: main.c stm32f1xx_it.c
    ../User/dwt/: bsp_dwt.c
    ../User/i2c/: bsp_i2c.c
    ../User/oled/: bsp_oled.c
    ../User/fonts/: bsp_fonts.c
    ../User/dht11/: bsp_dht11.c
    ../User/gpio/: bsp_gpio.c
    ../User/beep/: bsp_beep.c
    ../User/light/: bsp_light.c bsp_adc.c
    ../User/esp8266/: bsp_esp8266.c
    ../User/usart/: bsp_usart.c
    ../User/mqtt/: bsp_mqtt.c
  group DOC
    ../Doc/: Readme.txt
  group APP
    ../User/APP/oled_dht11/: app_oled_dht11.c
